# Keil uVision project usb_cdc.uvproj, settings and files
target usb_cdc (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: usb_cdc +hex
  link misc: REMOVEUNUSED
  group Source
    ./: usb_cdc.c stc_usb_cdc_32.LIB
