# Keil uVision project PWM_hardware_bk1.uvproj, settings and files
target PWM_hardware (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: PWM_hardware +hex
  link misc: REMOVEUNUSED, NOOVERLAY
  group AiCube
    ./Sources/: main.c
